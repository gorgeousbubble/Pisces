# IAR project k64_ipcam.ewp, settings and files
configuration Debug (ARM, debug)
  General.CoreVariant: 38
  General.FPU2: 1
  General.OGChipSelectEditMenu: MK64FN1M0xxx12  NXP MK64FN1M0xxx12
  General.OGHstacksize: 512
  General.OGIstacksize: 512
  General.OGCstacksize: 512
  ICCARM.CCDefines: CPU_MK64FN1M0VLL12; __FPU_PRESENT=1; ARM_MATH_CM4; FSL_RTOS_FREE_RTOS; DEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.CCIncludePath2: ..\..\include; ..\..\src\app; ..\..\src\service; ..\..\src\driver; ..\..\src\hal; ..\..\third_party\FreeRTOS\include; ..\..\third_party\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\third_party\FatFs\source; ..\..\third_party\KSDK\devices\MK64F12; ..\..\third_party\KSDK\devices\MK64F12\drivers; ..\..\third_party\KSDK\CMSIS\Include
  AARM.ADefines: CPU_MK64FN1M0VLL12
  ILINK.IlinkOutputFile: k64_ipcam.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../src/app/: main.c
  group Service
    ../../src/service/: log.c config_loader.c sys_manager.c file_mgr.c net_stack.c net_auth.c
  group Driver
    ../../src/driver/: cam_driver.c rtc_driver.c
  group HAL
    ../../src/hal/: board.c
  group FreeRTOS
    ../../third_party/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../../third_party/FreeRTOS/portable/MemMang/: heap_4.c
    ../../third_party/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FatFs
    ../../third_party/FatFs/source/: ff.c ffsystem.c ffunicode.c diskio.c
  group KSDK_Drivers
    ../../third_party/KSDK/devices/MK64F12/drivers/: fsl_clock.c fsl_uart.c fsl_i2c.c fsl_gpio.c fsl_ftm.c fsl_wdog.c fsl_sdhc.c
    ../../third_party/KSDK/devices/MK64F12/: system_MK64F12.c
    ../../third_party/KSDK/devices/MK64F12/iar/: startup_MK64F12.s
