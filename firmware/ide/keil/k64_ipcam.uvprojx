# Keil uVision project k64_ipcam.uvprojx, settings and files
target k64_ipcam_debug (ARM-ADS)
  device: MK64FN1M0xxx12 NXP
  pack: NXP.MK64F12_DFP.12.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: k64_ipcam +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK64FN1M0VLL12 __FPU_PRESENT=1 ARM_MATH_CM4 FSL_RTOS_FREE_RTOS
  c include: ..\..\include;..\..\src\app;..\..\src\service;..\..\src\driver;..\..\src\hal;..\..\third_party\FreeRTOS\include;..\..\third_party\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\third_party\FatFs\source;..\..\third_party\KSDK\devices\MK64F12;..\..\third_party\KSDK\devices\MK64F12\drivers;..\..\third_party\KSDK\CMSIS\Include
  asm define: CPU_MK64FN1M0VLL12
  group Application
    ../../src/app/: main.c
  group Service
    ../../src/service/: log.c config_loader.c sys_manager.c file_mgr.c net_stack.c net_auth.c
  group Driver
    ../../src/driver/: cam_driver.c rtc_driver.c
  group HAL
    ../../src/hal/: board.c
  group FreeRTOS
    ../../third_party/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../../third_party/FreeRTOS/portable/MemMang/: heap_4.c
    ../../third_party/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FatFs
    ../../third_party/FatFs/source/: ff.c ffsystem.c ffunicode.c diskio.c
  group KSDK_Drivers
    ../../third_party/KSDK/devices/MK64F12/drivers/: fsl_clock.c fsl_uart.c fsl_i2c.c fsl_gpio.c fsl_ftm.c fsl_wdog.c fsl_sdhc.c fsl_rtc.c
    ../../third_party/KSDK/devices/MK64F12/: system_MK64F12.c
    ../../third_party/KSDK/devices/MK64F12/arm/: startup_MK64F12.s
